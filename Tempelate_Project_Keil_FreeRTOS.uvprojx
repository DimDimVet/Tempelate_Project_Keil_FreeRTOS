# Keil uVision project Tempelate_Project_Keil_FreeRTOS.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Tempelate_Project_Keil_FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: F:\Tempelate_Project_Keil_FreeRTOS;.\FreeRTOS-Kernel\include;.\FreeRTOS-Kernel\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: app.c
  group RTOS
    ./FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c
    ./FreeRTOS-Kernel/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
